## sdkconfig.defaults
```kconfig
CONFIG_LV_COLOR_16_SWAP=y
CONFIG_LV_TFT_DISPLAY_CONTROLLER_ST7735S=y
CONFIG_LV_HOR_RES_MAX=132
CONFIG_LV_VER_RES_MAX=162
CONFIG_LV_DISP_BACKLIGHT_OFF=y
```
